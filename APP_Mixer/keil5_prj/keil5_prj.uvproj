# Keil uVision project keil5_prj.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: keil5_prj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\74HC573;..\..\BUTTON;..\..\DS18B20;..\..\exti_interrupt;..\..\IIC;..\..\LCD1602;..\..\motor_encode;..\..\mystring;..\..\pcf8591;..\..\PWM;..\..\software_timer;..\..\TIMER;..\..\UART
  group Source Group 1
    ../: main_001.c
    ../../LCD1602/: LCD1602.c
    ../../UART/: UART.c
    ../../BUTTON/: button.c
    ../../motor_encode/: motor_encode.c
    ../../TIMER/: timer.c
    ../../PWM/: pwm.c
    ../../software_timer/: software_timer.c
    ../../mystring/: mystring.c
    ../../exti_interrupt/: exti_interrupt.c
    ../../IIC/: iic.c
    ../../pcf8591/: pcf8591.c
    ../../DS18B20/: ds18b20.c
