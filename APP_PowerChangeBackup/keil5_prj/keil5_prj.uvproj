# Keil uVision project keil5_prj.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: keil5_prj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\74HC573;..\..\BUTTON;..\..\DS18B20;..\..\exti_interrupt;..\..\IIC;..\..\LCD1602;..\..\motor_encode;..\..\mystring;..\..\pcf8591;..\..\PWM;..\..\software_timer;..\..\TIMER;..\..\UART
  group Source Group 1
    ../: main_002.c
    ../../UART/: UART.c
    ../../pcf8591/: pcf8591.c
    ../../74HC573/: 74hc573.c
    ../../TIMER/: timer.c
    ../../software_timer/: software_timer.c
    ../../LCD1602/: LCD1602.c
    ../../mystring/: mystring.c
    ../../BUTTON/: button.c
    ../../IIC/: iic.c
