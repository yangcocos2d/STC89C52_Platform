# Keil uVision project keil5_prj.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: keil5_prj +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\74HC573;..\..\BUTTON;..\..\DS18B20;..\..\exti_interrupt;..\..\IIC;..\..\LCD1602;..\..\motor_encode;..\..\mystring;..\..\pcf8591;..\..\PWM;..\..\software_timer;..\..\TIMER;..\..\UART;..\..\AT24CXX;..\..\PCF8574;..\..\KeyBoard
  group Source Group 1
    ../: main_002.c
    ../../TIMER/: timer.c
    ../../software_timer/: software_timer.c
    ../../LCD1602/: LCD1602.c
    ../../mystring/: mystring.c
    ../../IIC/: iic.c
    ../../UART/: UART.c
    ../../PCF8574/: PCF8574.c
    ../../KeyBoard/: KeyBoard.c
